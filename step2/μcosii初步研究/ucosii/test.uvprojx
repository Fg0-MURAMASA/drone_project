# Keil uVision project test.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\Ports;.\Cfg;.\Core
  asm include: .\Cfg;.\Source;.\Ports;.\Core
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./Source/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Ports
    ./Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group Cfg
    ./Cfg/: app_cfg.h os_cfg.h
  group Start
    ./Start/: startup_stm32f10x_md.s
  group Core
    ./Core/: ucos_ii.h
  group User
    ./User/: main.c
    ./Listings/: test.map
